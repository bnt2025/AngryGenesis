<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_OQPSK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using OQPSK PHY</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2480000000</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>labels</key><value>[str(i) for i in range(11, 27)]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/sensor.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>5e6</value></param>
<param><key>analog_filter_ch0</key><value>0</value></param>
<param><key>cmix_mode_ch0</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>10e6</value></param>
<param><key>calibration_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>rx_gain</value></param>
<param><key>lna_path_ch0</key><value>2</value></param>
<param><key>lna_path_mini</key><value>1</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>calibration_ch1</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>digital_filter_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>serial</key><value>1D3A0C1C914B71</value></param>
<param><key>device_type</key><value>1</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>freq</value></param>
<param><key>samp_rate</key><value>400000</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>4e6</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
